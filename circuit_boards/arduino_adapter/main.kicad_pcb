# Repository nEDM-TUM/Temperature-Sensor-System

File README.md:

Temperature-Sensor-System
==============

Sensor network system built for the nEDM experiment.

Features
------------------
- Both temperature and humidity sensors can be connected at any sensor socket.
The sensor type will be automatically detected.
- High temperature and humidity accuracy: Temperature sensors are calibrated to ±0.1K and the humidity sensors to ±1.8%rH.
- A high number of connected sensors is supported. Currently 44 sensors are in use, however the system is designed to support at least 100 sensors and still be able to fulfill a sampling rate of 1Hz. If the sampling rate is allowed to be slower, up to 960 sensors are possible to share one Ethernet connection.
- The system supports a fast sample rate of at least 1Hz.
- We achieved a relatively low cost per sensor. The cost per sensor module is mostly defined by the sensor chip alone, which is about e7 for a precision temperature sensor and about e20 for a high quality humidity sensor. The cost for the printed circuit board and required components is less than e4 per board.
- Measurement results can be forwarded via TCP/IP to a CouchDB server, which is able to record the measurement data from all connected sensors.
- The sensor network provides a TCP/telnet user interface, for controlling and viewing of network parameters. This allows easy configuring and debugging of the system.
- Most of the system parameters like sampling rate or database IP addresses and insert functions are configurable at runtime.
- Plug and Play is supported for adding and removing sensors or even control units during runtime.

Directory structure
--------------------
```
.
+-- casings     // 3D CAD files for 3D printer
|   +-- adapter
|   +-- arduino
|   +-- cable_clamp
|   +-- collector
|   +-- humidity
|   +-- temperature
+-- circuit_boards      // Circuit schematic diagram and 
|   |                   // PCB schematic files created using KiCad
|   +-- 3x127_254_adapter       // A PCB chip adapter, 
|   |                           // used for breadboard debugging
|   +-- 4x127_254_adapter       // A PCB chip adapter, 
|   |                           // used for breadboard debugging
|   +-- arduino_adapter
|   +-- humidity
|   +-- kicad_library           // Footprint and Component
|   |                           // library files for KiCad
|   +-- order           // PCB assembly, which was sent to 
|   |                   // Fischer Leiterplatten for production
|   +-- sensor_board
|   +-- so8_breakout    // A PCB chip adapter, 
|   |                   // used for breadboard debugging
|   +-- temperature_board
+-- datasheets      // Datasheets for sensors, micro processor, etc.
+-- presentation    // Slides (tex files) for a project presentation
+-- registration    
|   +-- description     // Project description (tex files) 
|                       // used for registration
+-- report      // Main project documentation (tex files)
+-- shop_orders // Receipts of orders from hardware shops
+-- sofware
|   +-- avr_wcet_analyzer   // code of a WCET analyzer
|   |                       // for the AVR instruction set
|   +-- collector_board      
|   +-- ethernet_board        
|   +-- humidity_board      
|   +-- util        // Commonly used utility code
+-- squid_analysis      
|   +-- data            // Squid magnetic field measurement protocol.
|                       // For squid data please write a mail to us.
|   +-- evaluation      // Evaluation script of squid analysis data
```

Tips for developers
--------------------
- To prevent EEPROM from being corrupted on power cycles, the AVR integrated brownout detection should be enabled.
- To allow EEPROM storage to stay intact after reprogramming, set the corresponding fuse bit.
- As Arduino fuses are not possible to be programmed via the default Arduino programmer (using the Arduino boot loader), we removed the boot loader and use the ISP connector for programming.
- To not overload the voltage regulator, especially when driving multiple boards one should consider, that a significant portion of power is used to drive LEDs. So turning the LEDs off during normal operation will prevent overheating.
- When debugging and programming devices of the sensor network, one has to be very careful, to not provide different power sources, as this might cause unexpected results, which can lead to damage of the sensor network, as well as connected computers. By default the USBasp programmer provides the system with 5V power.
- Our makefiles currently do not support automatic detection of file dependencies, and source files to be compiled. All source files have to be specified explicitly and if changes to header files are made, a make clean should be performed before compiling the program.
- Be careful, when using the USART line or similar for generating debugging output. Transmitting debugging information takes relatively long time and might influence the system heavily, especially, when debugging timing critical code. LEDs or GPIO pins with an oscilloscope provide a faster but more complex way for debugging.

###For more details about our project, please read the report document. ###
Its tex file and needed images can be found in the folder _report_. You can use _make_ to compile the document.

## KiCad design circuit_boards/arduino_adapter/main.kicad_pcb

Board: 2 copper layers, 60.0 x 66.5 mm, 15 parts (4 on the bottom side), 31 nets.

Parts:
D1: LED; SM0603_big
P1, P4, P9, P11: CONN_8; Stiftleiste_8x1
P2, P3: CONN_6; Stiftleiste_6x1
P5: POW; Stiftleiste_2x1
P6: TWI; wannenstecker_2x3_rm254
P7: TWI_POW; wannenstecker_2x3_rm254
P8, P10: CONN_10; Stiftleiste_10x1
R1: 150; SM0805_big
R2, R3: 2k2; SM0603_big

Connections:
/LED: P9.6, P11.6, R1.2
/SCL: P6.2, P7.2, P8.1, P10.1, R2.1
/SDA: P6.4, P7.4, P8.2, P10.2, R3.1
GND: P1.2, P1.3, P4.2, P4.3, P5.1, P6.1, P6.3, P7.1, P7.3, P8.4, P10.4
unnamed: P1.1, P4.1
unnamed: P2.6, P3.6
unnamed: P2.5, P3.5
unnamed: P2.4, P3.4
unnamed: P2.3, P3.3
unnamed: P2.2, P3.2
unnamed: P2.1, P3.1
unnamed: P8.3, P10.3
unnamed: P8.5, P10.5
unnamed: P8.6, P10.6
unnamed: P8.7, P10.7
unnamed: P8.8, P10.8
unnamed: P8.9, P10.9
unnamed: P8.10, P10.10
unnamed: P9.1, P11.1
unnamed: P9.2, P11.2
unnamed: P9.3, P11.3
unnamed: P9.4, P11.4
unnamed: P9.5, P11.5
unnamed: P1.5, P4.5
unnamed: P1.6, P4.6
unnamed: P1.7, P4.7
unnamed: P1.8, P4.8
unnamed: P9.7, P11.7
unnamed: P9.8, P11.8
unnamed: D1.2, R1.1
VCC: D1.1, P1.4, P4.4, P5.2, P7.5, P7.6, R2.2, R3.2

## KiCad design circuit_boards/humidity/humidity_board.kicad_pcb

Parts:
C1, C3, C5, C6: 100nF
C2, C4: 10uF
D1, D2: LED
IC1: ATMEGA88-A; TQFP32
J1: RJ45
P1: ISP
P2: UART
R1, R2: 150
R3: 10k
R4, R5: 22k
R6: 120
R7, R8: 2k2
SW1: SW_RESET
U1: ST485
U2: HYT271

Connections:
/DI: IC1.10 ((PCINT22/OC0A/AIN0)PD6), U1.4 (DI)
/LED1: D1.2 (K), IC1.23 ((PCINT8/ADC0)PC0)
/LED2: D2.2 (K), IC1.24 ((PCINT9/ADC1)PC1)
/MISO: IC1.16 ((PCINT4/MISO)PB4), P1.9
/MOSI: IC1.15 ((PCINT3/OC2/MOSI)PB3), P1.1
/RESET: IC1.29 ((PCINT14/~RESET~)PC6), P1.5, R3.1, SW1.1
/RX: IC1.30 ((PCINT16/RXD)PD0), P2.3
/SCK: IC1.17 ((PCINT5/SCK)PB5), P1.7
/SCL: IC1.28 ((PCINT14/SCL/ADC5)PC5), R8.1, U2.4 (SCL)
/SDA: IC1.27 ((PCINT12/SDA/ADC4)PC4), R7.1, U2.1 (SDA)
/TX: IC1.31 ((PCINT17/TXD)PD1), P2.2
/za: C5.1, J1.1, R4.2, U1.6 (A)
/zb: J1.2, R5.1, R6.1, U1.7 (B)
GND: C1.1, C2.1, C3.2, C4.2, C6.2, IC1.3 (GND), IC1.5 (GND), IC1.21 (GND), J1.7, J1.8, J1.9 (SHIELD), P1.6, P1.8, P1.10, P2.1, R5.2, SW1.2, U1.5 (GND), U2.2 (GND)
unnamed: D1.1 (A), R1.1
unnamed: C5.2, R6.2
unnamed: D2.1 (A), R2.1
VCC: C1.2, C2.2, C3.1, C4.1, C6.1, IC1.4 (VCC), IC1.6 (VCC), IC1.18 (AVCC), J1.4, J1.5, P1.2, P2.4, R1.2, R2.2, R3.2, R4.1, R7.2, R8.2, U1.2 (nRE), U1.3 (DE), U1.8 (VCC), U2.3 (VCC)

Board: 2 copper layers, 100.0 x 20.0 mm, 25 parts (0 on the bottom side), 18 nets.

Other parts of the board:
m3_loch, m3_loch#2: VAL**; m3_loch

## KiCad design hardware/sensor_board/sensor_board.kicad_pcb

Parts:
C1, C23, C24: 10u
C2, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C25, C26, C27, C28, C29, C30, C31, C32: 100n
C3, C4: 22p
C5: 330nF
C6: 100nF
D1: LED1
D2: LED2
D3: LED3
D4: LED4
D5: LED_POW
IC1: ATMEGA88A-A; TQFP32
J1: RJ45_8P8C_8FACH
K1: pow_sel
P1: UART
P2: Shield
P3: i2c_pow
P4: i2c_chain
P5: 12Vin
P6: HOHLBUCHSE
P7: Vccin
P8: ISP
P9: 5Vin
R1, R9: 10k
R2, R3, R4, R5, R8: 150
R6, R7: 2k2
R10, R11, R12, R13, R14, R15, R16, R17, R22, R23, R24, R25, R26, R27, R28, R29: 22k
R18, R19, R20, R21, R30, R31, R32, R33: 120
R34: 0
SW1: SW1
SW2: SCHALTER_2POL
SW3: SW_RESET
U1: LM7805
U2, U3, U4, U5, U6, U7, U8, U9: ST485
X1: 20MHz

Connections:
+12V: C5.1, P5.2 (PM), P6.1, U1.1
/LED1: D1.2 (K), IC1.14 ((PCINT2/OC1B/~SS~)PB2)
/LED2: D2.2 (K), IC1.13 ((PCINT1/OC1A)PB1)
/LED3: D3.2 (K), IC1.12 ((PCINT0/CLKO/ICP1)PB0)
/LED4: D4.2 (K), IC1.11 ((PCINT23/AIN1)PD7)
/MISO: IC1.16 ((PCINT4/MISO)PB4), P8.9
/MOSI: IC1.15 ((PCINT3/OC2A/MOSI)PB3), P8.1
/RESET: IC1.29 ((PCINT14/~RESET~)PC6), P8.5, R9.2, SW3.1
/RX: IC1.30 ((PCINT16/RXD)PD0), P1.2
/SCK: IC1.17 ((PCINT5/SCK)PB5), P8.7
/SCL: IC1.28 ((PCINT14/SCL/ADC5)PC5), P3.2, P4.2, SW2.1
/SDA: IC1.27 ((PCINT12/SDA/ADC4)PC4), P3.4, P4.4, SW2.2
/SW1: IC1.10 ((PCINT22/OC0A/AIN0)PD6), R1.1, SW1.1
/TX: IC1.31 ((PCINT17/TXD)PD1), P1.3
/Vi2c: K1.1, P3.5, P3.6, P4.5, P4.6
/Vreg: C6.1, K1.3, P9.2 (PM), U1.3
/XTAL1: C3.2, IC1.7 ((PCINT6/XTAL1/TOSC1)PB6), X1.2
/XTAL2: C4.2, IC1.8 ((PCINT7/XTAL2/TOSC2)PB7), X1.1
/ZAC_01: IC1.23 ((PCINT8/ADC0)PC0), U2.1 (RO)
/ZAC_02: IC1.24 ((PCINT9/ADC1)PC1), U3.1 (RO)
/ZAC_03: IC1.25 ((PCINT10/ADC2)PC2), U4.1 (RO)
/ZAC_04: IC1.26 ((PCINT11/ADC3)PC3), U5.1 (RO)
/ZAC_05: IC1.32 ((PCINT18/INT0)PD2), U6.1 (RO)
/ZAC_06: IC1.1 ((PCINT19/OC2B/INT1)PD3), U7.1 (RO)
/ZAC_07: IC1.2 ((PCINT20/XCK/T0)PD4), U8.1 (RO)
/ZAC_08: IC1.9 ((PCINT21/OC0B/T1)PD5), U9.1 (RO)
/z1a: C7.1, J1.a1, R10.2, U2.6 (A)
/z1b: J1.a2, R14.1, R18.1, U2.7 (B)
/z2a: C8.1, J1.b1, R11.2, U3.6 (A)
/z2b: J1.b2, R15.1, R19.1, U3.7 (B)
/z3a: C9.1, J1.c1, R12.2, U4.6 (A)
/z3b: J1.c2, R16.1, R20.1, U4.7 (B)
/z4a: C10.1, J1.d1, R13.2, U5.6 (A)
/z4b: J1.d2, R17.1, R21.1, U5.7 (B)
/z5a: C11.1, J1.e1, R22.2, U6.6 (A)
/z5b: J1.e2, R26.1, R30.1, U6.7 (B)
/z6a: C12.1, J1.f1, R23.2, U7.6 (A)
/z6b: J1.f2, R27.1, R31.1, U7.7 (B)
/z7a: C13.1, J1.g1, R24.2, U8.6 (A)
/z7b: J1.g2, R28.1, R32.1, U8.7 (B)
/z8a: C14.1, J1.h1, R25.2, U9.6 (A)
/z8b: J1.h2, R29.1, R33.1, U9.7 (B)
GND: C1.2, C2.2, C3.1, C4.1, C5.2, C6.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, D5.2 (K), IC1.3 (GND), IC1.5 (GND), IC1.21 (GND), J1.a7, J1.a8, J1.b7, J1.b8, J1.c7, J1.c8, J1.d7, J1.d8, J1.e7, J1.e8, J1.f7, J1.f8, J1.g7, J1.g8, J1.h7, J1.h8, J1.s, P1.4, P3.1, P3.3, P4.1, P4.3, P5.1, P6.3, P7.1, P8.6, P8.8, P8.10, P9.1, R1.2, R14.2, R15.2, R16.2, R17.2, R26.2, R27.2, R28.2, R29.2, R34.2, SW3.2, U1.2, U2.2 (nRE), U2.3 (DE), U2.5 (GND), U3.2 (nRE), U3.3 (DE), U3.5 (GND), U4.2 (nRE), U4.3 (DE), U4.5 (GND), U5.2 (nRE), U5.3 (DE)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
unnamed: R7.2, SW2.4
unnamed: R6.2, SW2.3
unnamed: P2.1, R34.1
unnamed: C14.2, R33.2
unnamed: C12.2, R31.2
unnamed: C13.2, R32.2
unnamed: D4.1 (A), R5.1
unnamed: D3.1 (A), R4.1
unnamed: D5.1 (A), R8.2
unnamed: D2.1 (A), R3.1
unnamed: D1.1 (A), R2.1
unnamed: C7.2, R18.2
unnamed: C9.2, R20.2
unnamed: C10.2, R21.2
unnamed: C11.2, R30.2
unnamed: C8.2, R19.2
VCC: C1.1, C2.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, IC1.4 (VCC), IC1.6 (VCC), IC1.18 (AVCC), J1.a4, J1.a5, J1.b4, J1.b5, J1.c4, J1.c5, J1.d4, J1.d5, J1.e4, J1.e5, J1.f4, J1.f5, J1.g4, J1.g5, J1.h4, J1.h5, K1.2 (PM), P1.1, P7.2 (PM), P8.2, R2.2, R3.2, R4.2, R5.2, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R22.1, R23.1, R24.1, R25.1, SW1.2, U2.8 (VCC), U3.8 (VCC), U4.8 (VCC), U5.8 (VCC), U6.8 (VCC), U7.8 (VCC), U8.8 (VCC), U9.8 (VCC)

Board: 2 copper layers, 65.0 x 137.0 mm, 99 parts (0 on the bottom side), 60 nets.

Other parts of the board:
m3_loch, m3_loch#2, m3_loch#3: VAL**; m3_loch
