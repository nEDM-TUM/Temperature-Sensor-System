# Repository nEDM-TUM/Temperature-Sensor-System (continued)

## KiCad design hardware/temperature_board/temperature_board.kicad_pcb

Parts:
C1, C2, C4: 100nF
C3: 10uF
J1: RJ45
R1: 220
R2, R3: 22k
R4: 120
U1: TSIC50XF
U2: ST485

Connections:
/za: C4.1, J1.1, R2.2, U2.6 (A)
/zb: J1.2, R3.1, R4.1, U2.7 (B)
GND: C1.2, C2.2, C3.2, J1.7, J1.8, J1.9 (SHIELD), R3.2, U1.1, U2.5 (GND)
unnamed: C4.2, R4.2
unnamed: U1.2, U2.4 (DI)
unnamed: C1.1, R1.2, U1.3
VCC: C2.1, C3.1, J1.4, J1.5, R1.1, R2.1, U2.2 (nRE), U2.3 (DE), U2.8 (VCC)

Board: 2 copper layers, 76.0 x 20.0 mm, 13 parts (0 on the bottom side), 7 nets.

Other parts of the board:
m3_loch, m3_loch#2: VAL**; m3_loch

## Code that names these connections

File software/collector_board/board_support.h:

#ifndef BOARD_SUPPORT_H
#define BOARD_SUPPORT_H

#include <avr/io.h>

// LEDs:
#define LED1 PB2
#define LED2 PB1
#define LED3 PB0
#define LED4 PD7

#define LED1_PORT PORTB
#define LED2_PORT PORTB
#define LED3_PORT PORTB
#define LED4_PORT PORTD

#define LED1_DDR DDRB
#define LED2_DDR DDRB
#define LED3_DDR DDRB
#define LED4_DDR DDRD

// SWITCHES:
#define SW1 PD6
#define SW1_PORT PORTD
#define SW1_DDR DDRD

#endif

File software/humility/main.c (part):

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
#define SEND_START\
/*{*/\
  PORTD &= ~(1<<PD6);  \
  _delay_us(TSTART);\
  PORTD |= (1<<PD6);  \
  _delay_us(TSTART);\
  PORTD &= ~(1<<PD6);  \
/*}*/

#define SEND0\
/*{*/\
  _delay_us(TLONG);\
  PORTD |= (1<<PD6);  \
  _delay_us(TSHORT);\
/*}*/

#define SEND1\
/*{*/\
  _delay_us(TSHORT);\
  PORTD |= (1<<PD6);  \
  _delay_us(TLONG);\
/*}*/

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  int8_t index = 0;\
  int8_t byte_copy = byte;\
  for(index=7; index >= 0; index--){\
    PORTD &= ~(1<<PD6);  \
    if(byte_copy & (1 << 7)){\
      SEND1\
    }else{\
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void sendBYTE(uint8_t byte){
  int8_t index = 0;
  for(index=7; index >= 0; index--){
    PORTD &= ~(1<<PD6);
    if(byte & (1 << 7)){
      SEND1
    }else{
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
  printf("Start\n\r");
  // printf("OC0B = %d\n\r", PORTD);
  // PD6 as output port
	 DDRD |= (1<<PD6);
   PORTC |= (1<<PC4);
   PORTC |= (1<<PC5);
  // TODO debug, LED blink
	DDRC |= (1<<PC0);
  PORTC = PORTC ^ (1<<PC0);
    _delay_ms(500);
  PORTC = PORTC ^ (1<<PC0);
    _delay_ms(500);
  PORTC = PORTC ^ (1<<PC0);
    _delay_ms(500);
  PORTC = PORTC ^ (1<<PC0);
    _delay_ms(500);
  PORTC = PORTC ^ (1<<PC0);

  // TODO debug, LED blink
	DDRC |= (1<<PC1);
  PORTC = PORTC ^ (1<<PC1);
    _delay_ms(500);
  PORTC = PORTC ^ (1<<PC1);
    _delay_ms(500);
  PORTC = PORTC ^ (1<<PC1);
    _delay_ms(500);
  PORTC = PORTC ^ (1<<PC1);
    _delay_ms(500);
  PORTC = PORTC ^ (1<<PC1);

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void led0(){
  // TODO debug, LED blink
  _delay_ms(500);
  PORTC = PORTC ^ (1<<PC0);
  _delay_ms(500);
  PORTC = PORTC ^ (1<<PC0);
}
void led1(){
  // TODO debug, LED blink
  _delay_ms(500);
  PORTC = PORTC ^ (1<<PC1);
  _delay_ms(500);
  PORTC = PORTC ^ (1<<PC1);
}

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
## Commit log (part)

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2014-04-27 modules
2014-04-27 add st485
2014-04-27 7805 schematic library
2014-04-27 board started
2014-04-27 modify sensor board schematik
2014-04-27 sensor board pcb routing started
2014-04-28 sensor_board: all connected
2014-04-28 zones added
2014-04-28 comments in schematics
2014-04-28 fixed unconnected zac wire
2014-04-29 modify again
2014-04-29 again
2014-04-29 begin with pcb
2014-04-29 add netlist and pcb
2014-04-30 sensor_board complete
2014-04-30 temperature board pcb finished
2014-04-30 modify
2014-04-30 begin with humidity board pcb
2014-04-30 add m3 schraube
2014-05-01 humidity pcb finished
2014-05-01 checking
2014-05-01 change sensor modules
2014-05-06 sensor_board final version
2014-05-06 sensor board smaller
2014-05-06 change humidity
2014-05-06 optimal temperature pcb
2014-05-06 humidity smaller
2014-05-06 fill
2014-05-06 humidity led pos + zones
2014-05-07 finalized boards for production
2014-05-07 breakout boards + order
2014-05-07 pcb for adaptor board
2014-05-07 moved modules
2014-05-07 moved again...
2014-05-07 order
2014-05-07 order_final
2014-05-07 order2_s1
2014-05-07 order2_s2
2014-05-07 order2_s3
2014-05-07 all boards
2014-05-07 2 humidity together
2014-05-07 2 temp boards
2014-05-07 10 temp sensor work
2014-05-07 sensor board rotated
2014-05-08 einzeln
2014-05-08 order4 is plotting :)
2014-05-08 gerber files
2014-05-17 add latex git ignore
2014-05-17 add some other gitignore
2014-05-17 add document rahmen
2014-05-17 new kicad model, forgot to commit
2014-05-18 add table of contents
2014-05-18 fixed ^M and filenames
2014-05-18 moved report to main tree
2014-05-20 88 test
2014-05-20 software for collector board
2014-05-20 all ports are read
2014-05-20 led blinks on connection state change
2014-05-20 atmega88 datasheet, ethernet_i2c_test now supports 8 channels
2014-05-20 crc correct check
2014-05-20 Hymility software testversion 1 with delay method
2014-05-21 5 bbyte checksum checked
2014-05-22 clear code
2014-05-22 clear codes
2014-05-22 debug method 2
2014-05-22 debugging
2014-05-22 debugging ..
2014-05-22 renamed humidity
2014-05-26 precision analysis for tsic
2014-05-26 added i2c pullups to humidity board
2014-05-26 chaining test
2014-05-28 for put all together
2014-05-28 strange pcb is saved in temperature_board-append.kicad_pcb
2014-05-28 finished
2014-05-28 finished but crash by plot gerb file
2014-05-28 collectorboard: startet implementing polling
2014-05-28 3 humidity boards but just 19 temperature
2014-05-28 3 humidity but 19 temperature
2014-05-28 23 temperature 2 humility
2014-05-28 i2c...
2014-05-28 finished and can be plot
2014-05-28 save
2014-05-28 collector board: twi state machine
2014-05-29 fixed twi state machine, now non blocking
2014-05-29 collector_board compiles
2014-05-29 ethernet board i2c interface implemented
2014-05-29 debug timer
2014-05-29 convert to ZAC protocol method 2 works
2014-05-29 start configuration program
2014-05-29 debugging debugging ...
2014-05-29 nothing works
2014-05-31 i2c works quite stable for 1 board
2014-05-31 wenwen review
2014-05-31 i2c works - again - one has to send stop before start
2014-05-31 improve computing humility sensor data
2014-05-31 i2c ethernet: use wait timeout correctly
2014-05-31 also for ethernet board
2014-05-31 *100
2014-05-31 fix hum temperature
2014-05-31 fixed temperature conversion 10000->100
2014-05-31 cleanup + implemented general call support
2014-05-31 change CRC implementation
2014-06-01 crc implementation
2014-06-01 bugfix
2014-06-01 revert
2014-06-01 changed byte order for interpreter functions
2014-06-01 cleanup analyze function
2014-06-01 also for collection board
2014-06-01 clean up CRC code
2014-06-01 fixed interpret + analyze for new byte order
2014-06-01 fixed random error tsic
2014-06-01 integrate configuration into main
2014-06-01 change to cpp
2014-06-01 no delay
2014-06-01 moved collector board interface to separate file
2014-06-01 started cleaning up collector_board code
2014-06-01 fixed usart c/cpp compatibility
2014-06-01 continued cleaning up collector_board
2014-06-01 collector compiles
2014-06-01 everything works again after restructuring
2014-06-01 correct type usage
2014-06-01 started implementing packet generation
2014-06-01 first step
2014-06-02 somehow works, but we lost sensor 8 during transmission
2014-06-02 fixed losing 8th sensor. (just did not receive enough data)
2014-06-03 test decimal point output
2014-06-03 implemented i2c scanning
2014-06-03 started implementing eeprom configuration
2014-06-03 new structure
2014-06-03 collector board: config works
2014-06-03 i2c specification document
2014-06-04 config files added
2014-06-04 implemented set_addr command for setting TWI address
2014-06-04 collector board compiles
2014-06-04 implemented
2014-06-04 bugsfix
2014-06-04 add some cases
2014-06-04 bugs fix
2014-06-05 small fixed, cleanup
2014-06-05 with progmem
2014-06-05 user interface: ser twi address command
2014-06-05 fix char \0 problem
2014-06-06 something do not know
2014-06-07 set twi addr works
2014-06-07 clean up collector twi interface
2014-06-07 implement reset
2014-06-07 test
2014-06-07 function to print result to socket
2014-06-07 structure cmd
2014-06-09 iimplemented simple do measurement command
2014-06-09 compiles
2014-06-10 collector board is broken, somehow config save does not work
2014-06-11 set twi addr works again
2014-06-11 stabilized twi communication
2014-06-11 finish unstructure
2014-06-11 finish
2014-06-11 improved performance for twi_wait_timeout
2014-06-12 add file
2014-06-12 debuggen
2014-06-12 response
2014-06-12 fixed socket file aproach
2014-06-12 forgot file... ;)
2014-06-14 event loop approach compiles
2014-06-14 debugging output
2014-06-14 before i implement read
2014-06-14 basic test works | bug: res confligt with twi bus -> started mutex implementation
2014-06-14 twi bus mutex in user interface
2014-06-14 finish with sock stream
2014-06-14 sock stream implement
2014-06-14 configurable interval now working
2014-06-14 construct
2014-06-14 add user cmd file
2014-06-14 implemented scan after before every measurement
2014-06-14 idea for lockup bug
2014-06-14 fixed deadlock problem
2014-06-14 fuses howto update: brown out detection for eeprom corruption prevention
2014-06-14 twiaddr adjusted, still wron parameter parsing
2014-06-14 twiaddr - madness
2014-06-14 add eeprom_storage
2014-06-15 fix errors
2014-06-15 updated buglist
2014-06-15 do progmem
2014-06-15 still instable
2014-06-15 implemented led cmd
2014-06-15 implemented LED cmd, changed socket and cmd handling alot, now buggy
2014-06-15 led fixes
2014-06-17 fixed checksum always wrong error for humidity eval
2014-06-17 moved checksum to util
2014-06-17 i2c checksum evaluated
2014-06-17 start define macro
2014-06-19 fixec temp checksum (now also containing padding)
2014-06-21 many images :)
2014-06-21 report schematic images
2014-06-22 report: bib
2014-06-22 zac implementation started
2014-06-22 implement eeprom and add some macro
2014-06-22 write pseudo code for sending result
2014-06-22 zac limits
2014-06-23 wcet stuff to report
2014-06-23 wcet report image description
2014-06-26 renamed lots of files, code is compiling again
2014-06-26 adjusted makefiles for eeprom and fuses
2014-06-27 naming conventions
2014-06-27 repo cleanup
2014-06-30 report continued
2014-06-30 report: packet format
2014-06-30 report: wrap long lines
2014-06-30 connect to server failed
2014-07-01 % style shell. does not work :(
2014-07-01 shell prompt implemented
2014-07-01 ui improvements
2014-07-01 cleanup
2014-07-01 debug
2014-07-02 send data to db works
2014-07-02 send data to db
2014-07-02 some modify
2014-07-03 fix some little logic problems
2014-07-03 new cmd
2014-07-03 command comments and names: fixed and completed
2014-07-04 comments
2014-07-09 bugfix d.v
2014-07-09 fixme, grammar, ...
2014-07-09 fix sock problem
2014-07-09 clean code
2014-07-09 buglist, cleanup, debugging enabled printf CHANGE BACK AFTER FIX
2014-07-10 add newline
2014-07-10 rm doMeasurement
2014-07-10 change cmd count
2014-07-10 improved db communication speed (replies) -> arduino library plugin for w5100 clear buffer support
2014-07-10 clear printf
2014-07-10 printf => putc
2014-07-10 new version
2014-07-13 add install plan
2014-07-16 avaluation script for squid data
2014-07-16 second measurement of squid data log file
2014-07-16 started presentation
2014-07-16 presentation cont.
2014-07-16 presentation cont
2014-07-16 presentation continued
2014-07-16 pres: images
2014-07-16 plan2_color updated
2014-07-16 presentation
2014-07-16 add db image
2014-07-17 add set img
2014-07-20 change and add install plan
2014-07-20 report: collector board hardware description
2014-07-20 report: collector board complete
2014-07-20 report cleanup
2014-07-20 fix some details
2014-07-20 do some fix
2014-07-20 reviewed hymility codes
2014-07-21 report: rs485 described
2014-07-21 report: described i2c
2014-07-21 report: isp programmer described
2014-07-22 fix found bugs
2014-07-22 squid evaluate script update
2014-07-22 humidity fuses, ethernet: config size
2014-07-22 fix d.v
2014-07-22 add interval to eeprom
2014-07-24 default config change
2014-07-24 comments, fixmes, etc. code proofreading
2014-07-24 use watchdog timer (2s)
2014-07-25 do fixme
2014-07-25 debug 1
2014-07-25 debug 2
2014-07-25 debug ..... located bug in net_sendResultToDB but not in connect_db we reach line 212!
2014-07-25 debug: locate inside net_sendResultToDB
2014-07-30 stable version 0.1
2014-07-31 report: started ui command description
2014-07-31 report: ui cmd description
2014-08-03 report: toolchain continued
2014-08-22 report: small changes
2014-08-22 rep: ether net doc continued
2014-08-27 adjust install plan
2014-08-27 report: KiCad
2014-08-27 report: hyt + citations
2014-09-05 all case versions, - chaos
2014-09-05 removed irrelevant cases CAD files
2014-09-05 added solidworks file for hum and temp, but might be out of date. FIXME: stp and stl files needed for temperature and humidity cases
2014-09-05 repository cleanup
2014-09-05 report: structure
2014-09-06 report: ethernet hardware
2014-09-06 report: etnernetboard - eventloop description
2014-09-07 report: receiving of measurement results
2014-09-07 report: networking started
2014-09-07 review sensors part
2014-09-07 report: ethernet board software finished
2014-09-07 review protocols capital
2014-09-07 write some bla
2014-09-07 review toolchain
2014-09-07 review temperature board
2014-09-07 review humidity hardware part
2014-09-07 write sth to humidity board
2014-09-08 report: fixed some fixmes
2014-09-08 add zac encoding img, but not very happy with it
2014-09-08 finish zac encoding
2014-09-10 report: pin picture reference
2014-09-11 report: casings
2014-09-12 images for boards + report appedix moved schematics
2014-09-13 report: install plan completed
2014-09-13 report: images
2014-09-13 add crc description
2014-09-13 improve crc part
2014-09-13 review collector hardware
2014-09-13 report: problems and tips
2014-09-13 reviewed until Ethernet board
2014-09-13 umstructure
2014-09-13 add instroduction chapter rahmen
2014-09-13 review ethernet hardware
2014-09-14 report: into - background
2014-09-14 report: features chapter
2014-09-14 review ethernet software
2014-09-15 reviewed till deployment installation
2014-09-15 review till end
2014-09-15 report: corrections until 3.3 collector board
2014-09-15 report: corrections until ethernet board
2014-09-15 report: cage citation
2014-09-15 review introduction
2014-09-15 add git repository subsection
2014-09-15 report: corrections until deployment
2014-09-15 rename Anmeldung folder
2014-09-15 remove orders
2014-09-15 report: correct all
2014-09-15 add a fixme
2014-09-15 report spell checking
2014-09-15 report fix compile bug
2014-09-15 report: git repo
2014-09-15 add readme
2014-09-15 modify readme
2014-09-15 add makefile for tex
2014-09-15 change makefile
2014-09-15 improve makefile
2014-09-15 readme
2014-09-15 add makefile to presentation
2014-09-16 makefiles modified to create build foler automatically
2014-09-17 report: zac sampling complete measurement fixed
2014-09-17 add transmission structure
2014-09-17 improve hyt transmission structure
2014-09-17 report: transmission structute hyt, corrected
2014-09-17 report layout
2014-09-17 report: appendix renaming
2014-09-17 correct care to undefined
